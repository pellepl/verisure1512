# Keil uVision project Project.uvprojx, settings and files
target STM327x6G-EVAL_USBH-FS (ARM-ADS)
  device: STM32F756IG STMicroelectronics
  pack: Keil.STM32F7xx_DFP.0.0.3
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM327x6G-EVAL_USBH-FS
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F756xx,USE_STM32756G_EVAL,USE_USB_FS,USE_IOEXPANDER
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\..\..\..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Class\AUDIO\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Class\HID\Inc;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers;..\..\..\..\..\..\Drivers\BSP\STM32756G_EVAL;..\..\..\..\..\..\Utilities\Log
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f756xx.s
  group Application/User
    ../Src/: stm32f7xx_it.c usbh_conf.c menu.c main.c
  group Application/User/MSC
    ../Src/: msc_explorer.c file_operations.c usbh_diskio.c msc_menu.c
  group Application/User/AUDIO
    ../Src/: audio_menu.c audio.c audio_explorer.c
  group Application/User/HID
    ../Src/: hid_menu.c keyboard.c mouse.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/FatFS/Drivers
    ../../../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_ltdc.c stm32f7xx_ll_fmc.c stm32f7xx_hal_flash.c stm32f7xx_hal_sd.c stm32f7xx_hal_pwr.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_cortex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_i2c.c stm32f7xx_hal_sdram.c stm32f7xx_hal_rcc.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_dma.c stm32f7xx_ll_usb.c stm32f7xx_hal_gpio.c stm32f7xx_hal.c stm32f7xx_hal_sram.c stm32f7xx_hal_hcd.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_i2c_ex.c
  group Middlewares/STM32_USBH_Library/Class/HID
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Src/: usbh_hid.c usbh_hid_parser.c usbh_hid_keybd.c usbh_hid_mouse.c
  group Middlewares/FatFS/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c ff.c diskio.c
  group Utilities
    ../../../../../../Utilities/Log/: lcd_log.c
  group Middlewares/STM32_USBH_Library/Class/AUDIO
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/AUDIO/Src/: usbh_audio.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32756G_EVAL
    ../../../../../../Drivers/BSP/STM32756G_EVAL/: stm32756g_eval.c stm32756g_eval_sd.c stm32756g_eval_sdram.c stm32756g_eval_lcd.c stm32756g_eval_io.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_pipes.c usbh_ioreq.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
target STM327x6G-EVAL_USBH-HS (ARM-ADS)
  device: STM32F756IG STMicroelectronics
  pack: Keil.STM32F7xx_DFP.0.0.3
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x1000) IRAM2(0x10000000,0x4000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM327x6G-EVAL_USBH-HS
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F756xx,USE_STM32756G_EVAL,USE_USB_HS,USE_IOEXPANDER
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  memory RVCT10: RAM 0x10000000 size 0x4000
  link misc: --diag_suppress=L6329
target STM327x6G-EVAL_USBH-HS-IN-FS (ARM-ADS)
  device: STM32F756IG STMicroelectronics
  pack: Keil.STM32F7xx_DFP.0.0.3
  cpu: as above
  output: STM327x6G-EVAL_USBH-HS-IN-FS
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F756xx,USE_STM32756G_EVAL,USE_USB_HS,USE_IOEXPANDER,USE_USB_HS_IN_FS
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  memory RVCT10: RAM 0x10000000 size 0x4000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 4.1.0
