# Keil uVision project Project.uvprojx, settings and files
target STM327x6G_EVAL (ARM-ADS)
  device: STM32F756IG STMicroelectronics
  pack: Keil.STM32F7xx_DFP.0.0.3
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM327x6G_EVAL +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F756xx,USE_STM32756G_EVAL,USE_IOEXPANDER
  c misc: --C99 --diag_suppress 167
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32756G_EVAL;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components;..\..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include\;..\..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include\ipv4                                                              ;..\..\..\..\..\..\Middlewares\Third_Party\LwIP\system;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM7\r0p1;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\..\..\..\..\Utilities;..\..\..\..\..\..\Utilities\Log
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress 167
  group Application/Utilities
    ../../../../../../Utilities/Log/: lcd_log.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_pwr.c stm32f7xx_hal_i2c.c stm32f7xx_hal_gpio.c stm32f7xx_ll_fmc.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal.c stm32f7xx_hal_sdram.c stm32f7xx_hal_uart.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_ltdc.c
  group Drivers/BSP/STM32756G_EVAL
    ../../../../../../Drivers/BSP/STM32756G_EVAL/: stm32756g_eval.c stm32756g_eval_lcd.c stm32756g_eval_sdram.c stm32756g_eval_io.c
  group Doc
    ../: readme.txt
  group Middlewares/LwIP/Api
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: api_msg.c sockets.c api_lib.c netdb.c err.c netbuf.c tcpip.c netifapi.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/LwIP/Netif
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: etharp.c
    ../../../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: queue.c list.c tasks.c croutine.c timers.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group Middlewares/LwIP/Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: tcp_in.c init.c stats.c pbuf.c udp.c raw.c tcp.c lwip_timers.c sys.c dhcp.c tcp_out.c def.c dns.c memp.c mem.c netif.c
  group Application/MDK-ARM
    ./: startup_stm32f756xx.s
  group Middlewares/LwIP/Core/IPv4
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: igmp.c inet_chksum.c autoip.c ip.c inet.c ip_frag.c ip_addr.c icmp.c
  group Application/User
    ../Src/: httpserver-netconn.c main.c ethernetif.c fs.c stm32f7xx_it.c app_ethernet.c
software components: CMSIS:CORE 4.1.0
