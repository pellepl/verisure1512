# Keil uVision project Project.uvprojx, settings and files
target STM327x6G_EVAL (ARM-ADS)
  device: STM32F756IG STMicroelectronics
  pack: Keil.STM32F7xx_DFP.0.0.3
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM327x6G_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F756xx,USE_STM32756G_EVAL,USE_IOEXPANDER
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\..\..\..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32756G_EVAL;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM7\r0p1;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_i2c.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_cortex.c stm32f7xx_hal_gpio.c stm32f7xx_ll_fmc.c stm32f7xx_hal_dma.c stm32f7xx_hal_sd.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c
  group Drivers/BSP/STM32756G_EVAL
    ../../../../../../Drivers/BSP/STM32756G_EVAL/: stm32756g_eval_sd.c stm32756g_eval.c stm32756g_eval_io.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/FatFs/Drivers
    ../../../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Middlewares/FatFs/Options
    ../../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: queue.c list.c croutine.c tasks.c timers.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group Application/MDK-ARM
    ./: startup_stm32f756xx.s
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Application/User
    ../Src/: main.c stm32f7xx_it.c
software components: CMSIS:CORE 4.1.0
