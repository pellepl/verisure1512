# Keil uVision project Project.uvprojx, settings and files
target STM327x6G_EVAL_MB1063 (ARM-ADS)
  device: STM32F756IG STMicroelectronics
  pack: Keil.STM32F7xx_DFP.0.0.3
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x1000) IRAM2(0x10000000,0x4000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM327x6G_EVAL_MB1063
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F756xx,USE_STM32756G_EVAL,USE_IOEXPANDER,USE_MB1063
  c misc: --C99
  c include: ..\Inc;..\Demo;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32756G_EVAL;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components;..\..\..\..\..\..\Middlewares\ST\STemWin\inc;..\..\..\..\..\..\Utilities;..\..\..\..\..\..\Utilities\Fonts
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  memory RVCT10: RAM 0x10000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/BSP/STM32756G_EVAL
    ../../../../../../Drivers/BSP/STM32756G_EVAL/: stm32756g_eval_io.c stm32756g_eval.c stm32756g_eval_ts.c stm32756g_eval_sdram.c
  group Middlewares/STemWin/Config
    ../Src/: GUIConf.c LCDConf_stm32756g_eval_MB1063.c
    ../../../../../../Middlewares/ST/STemWin/OS/: GUI_X.c
  group Middlewares/STemWin/inc
    ../../../../../../Middlewares/ST/STemWin/inc/: GUI_SetOrientationCX.h BUTTON.h GUIDRV_Lin.h CHECKBOX.h WM.h GUI.h GUI_FontIntern.h FRAMEWIN.h SCROLLBAR.h GUI_Type.h DROPDOWN.h GUIDRV_Lin_Opt_16.h GRAPH.h RADIO.h GUI_JPEG_Private.h DIALOG.h RADIO_Private.h LISTVIEW_Private.h GUIDRV_Template.h LISTBOX_Private.h IMAGE.h MULTIPAGE.h GUIDRV_Generic.h SLIDER_Private.h GUIDRV_DCache_Private.h MULTIEDIT.h GUI_HOOK.h WIDGET.h GUIDRV_FlexColor.h DIALOG_Intern.h PROGBAR.h GUI_BMP_Private.h GUIDRV_Lin_Opt_32.h SPINBOX.h WM_Intern.h GUI_ARRAY_Private.h GUI_ConfDefaults.h CHOOSECOLOR.h SCROLLBAR_Private.h GUI_VNC.h GUI_ARRAY.h HEADER_Private.h GUIDRV_Lin_Opt_8.h LISTWHEEL_Private.h LCD_Protected.h GUI_Version.h GUI_SPRITE_Private.h MESSAGEBOX.h MENU_Private.h EDIT_Private.h GUIDRV_FlexColor_Private.h MENU.h LCD_SIM.h SPINBOX_Private.h TREEVIEW_Private.h LISTVIEW.h GUI_SetOrientation.h EDIT.h SLIDER.h LCD.h LCD_ConfDefaults.h TEXT.h GRAPH_Private.h GUIDRV_Lin_Private.h GUIDRV_Lin_Opt_24.h MULTIPAGE_Private.h WINDOW_Private.h PROGBAR_Private.h HEADER.h CALENDAR.h WM_GUI.h LISTBOX.h CHOOSEFILE.h TREEVIEW.h LISTWHEEL.h GUI_Private.h IMAGE_Private.h DROPDOWN_Private.h GUIDRV_TemplateI.h CHECKBOX_Private.h GUI_GIF_Private.h ICONVIEW_Private.h LCD_Private.h TEXT_Private.h GUIDRV_Dist.h GUIDRV_TemplateI_Private.h GUI_Debug.h BUTTON_Private.h ICONVIEW.h GUIDRV_DCache.h FRAMEWIN_Private.h Global.h GUIDRV_NoOpt_1_8.h
  group Middlewares/STemWin/Lib
    ../../../../../../Middlewares/ST/STemWin/Lib/: STemWin528_CM7_Keil.lib
  group Application/User
    ../Src/: main.c calibration.c rtc.c stm32f7xx_it.c
  group Application/Demo
    ../Demo/: GUIDEMO_Resource.c GUIDEMO_BarGraph.c GUIDEMO_Listview.c GUIDEMO_Skinning.c GUIDEMO.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_Treeview.c GUIDEMO_AntialiasedText.c GUIDEMO_Start.c GUIDEMO_Cursor.c GUIDEMO_RadialMenu.c GUIDEMO_ZoomAndRotate.c GUIDEMO_Bitmap.c GUIDEMO_Conf.c GUIDEMO_WashingMachine.c GUIDEMO_VScreen.c GUIDEMO_ColorBar.c GUIDEMO_TransparentDialog.c GUIDEMO_Speed.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Automotive.c GUIDEMO_Fading.c GUIDEMO_Speedometer.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/exc7200/: exc7200.c
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../../Drivers/BSP/Components/ts3510/: ts3510.c
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_ltdc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_flash.c stm32f7xx_hal_sdram.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_crc.c stm32f7xx_hal.c stm32f7xx_hal_tim.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_rtc.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_dma.c stm32f7xx_ll_fmc.c stm32f7xx_hal_pwr.c stm32f7xx_hal_i2c.c stm32f7xx_hal_uart.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_rng.c
  group Application/MDK-ARM
    ./: startup_stm32f756xx.s
software components: CMSIS:CORE 3.40.0
