# Keil uVision project Project.uvprojx, settings and files
target STM327x6G_EVAL (ARM-ADS)
  device: STM32F756IG STMicroelectronics
  pack: Keil.STM32F7xx_DFP.0.0.3
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM327x6G_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F756xx,USE_STM32756G_EVAL,USE_IOEXPANDER
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\..\..\..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32756G_EVAL;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers;..\..\..\..\..\..\Middlewares\Third_Party\LibJPEG\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_pwr_ex.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_flash.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_pwr.c stm32f7xx_hal_i2c.c stm32f7xx_hal_gpio.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sd.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal.c stm32f7xx_hal_sdram.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_ltdc.c
  group Drivers/BSP/STM32756G_EVAL
    ../../../../../../Drivers/BSP/STM32756G_EVAL/: stm32756g_eval_sd.c stm32756g_eval.c stm32756g_eval_lcd.c stm32756g_eval_sdram.c stm32756g_eval_io.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/FatFs/Drivers
    ../../../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Middlewares/LibJPEG
    ../../../../../../Middlewares/Third_Party/LibJPEG/source/: jccolor.c jaricom.c jddctmgr.c jquant1.c jcparam.c jdapimin.c jdcoefct.c jfdctflt.c jcsample.c jcmaster.c jmemmgr.c jcmainct.c jdapistd.c jdhuff.c jdcolor.c jidctint.c jcomapi.c jchuff.c jdinput.c jcdctmgr.c jcapimin.c jcinit.c jdmerge.c jccoefct.c jfdctint.c jdatadst.c jcarith.c jctrans.c jidctfst.c jdarith.c jerror.c jfdctfst.c jdtrans.c jdmarker.c jdatasrc.c jdpostct.c jdsample.c jmemnobs.c jdmainct.c jcprepct.c jcapistd.c jidctflt.c jutils.c jquant2.c jcmarker.c jdmaster.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c diskio.c ff.c
  group Application/MDK-ARM
    ./: startup_stm32f756xx.s
  group Application/User
    ../Src/: decode.c encode.c main.c stm32f7xx_it.c
software components: CMSIS:CORE 4.1.0
