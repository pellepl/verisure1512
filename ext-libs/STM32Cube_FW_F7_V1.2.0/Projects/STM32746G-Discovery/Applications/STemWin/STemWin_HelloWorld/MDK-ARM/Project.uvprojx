# Keil uVision project Project.uvprojx, settings and files
target STM32746G_DISCOVERY (ARM-ADS)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.0.0.3
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32746G_DISCOVERY
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx,USE_STM32756G_DISCOVERY
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32746G-Discovery;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components;..\..\..\..\..\..\Middlewares\ST\STemWin\inc;..\..\..\..\..\..\Utilities;..\..\..\..\..\..\Utilities\Fonts
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Application/User
    ../Src/: BASIC_HelloWorld.c main.c stm32f7xx_it.c
  group Drivers/BSP/STM32746G_DISCOVERY
    ../../../../../../Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_sdram.c
  group Middlewares/STemWin/Lib
    ../../../../../../Middlewares/ST/STemWin/Lib/: STemWin528_CM7_Keil.lib
  group Middlewares/STemWin/inc
    ../../../../../../Middlewares/ST/STemWin/inc/: LISTBOX_Private.h GUI_BMP_Private.h MESSAGEBOX.h GUIDRV_DCache_Private.h LCD_SIM.h TREEVIEW_Private.h IMAGE.h GUIDRV_Lin_Opt_24.h GUI_ConfDefaults.h LISTBOX.h GUIDRV_Lin_Private.h EDIT.h HEADER.h SPINBOX.h MULTIEDIT.h WM_GUI.h GUI_SetOrientationCX.h IMAGE_Private.h LISTWHEEL_Private.h PROGBAR.h CHOOSEFILE.h GUIDRV_FlexColor_Private.h CHECKBOX_Private.h CHECKBOX.h GUIDRV_Lin_Opt_16.h GUIDRV_Lin_Opt_32.h EDIT_Private.h SLIDER_Private.h MULTIPAGE_Private.h GUIDRV_Template.h SCROLLBAR.h PROGBAR_Private.h DROPDOWN_Private.h HEADER_Private.h CALENDAR.h LCD.h TREEVIEW.h GUIDRV_Lin_Opt_8.h GUIDRV_TemplateI.h DIALOG.h GUIDRV_Generic.h GUI_FontIntern.h BUTTON_Private.h GUI_Private.h LCD_Protected.h ICONVIEW.h GUI_Debug.h GUI.h GUIDRV_FlexColor.h LISTVIEW.h RADIO_Private.h GUI_HOOK.h CHOOSECOLOR.h MENU.h SLIDER.h WM.h WIDGET.h GUI_JPEG_Private.h DIALOG_Intern.h BUTTON.h GUI_VNC.h GRAPH.h LCD_ConfDefaults.h Global.h WINDOW_Private.h LISTWHEEL.h SCROLLBAR_Private.h GUIDRV_NoOpt_1_8.h ICONVIEW_Private.h GRAPH_Private.h RADIO.h GUIDRV_TemplateI_Private.h SPINBOX_Private.h LCD_Private.h GUI_SetOrientation.h MENU_Private.h WM_Intern.h GUIDRV_Dist.h GUI_ARRAY.h GUI_ARRAY_Private.h TEXT_Private.h GUI_Version.h GUIDRV_Lin.h DROPDOWN.h FRAMEWIN.h GUIDRV_DCache.h GUI_GIF_Private.h LISTVIEW_Private.h MULTIPAGE.h GUI_SPRITE_Private.h TEXT.h FRAMEWIN_Private.h GUI_Type.h
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_cortex.c stm32f7xx_hal.c stm32f7xx_hal_dma.c stm32f7xx_hal_ltdc.c stm32f7xx_ll_fmc.c stm32f7xx_hal_rcc.c stm32f7xx_hal_tim.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_sdram.c stm32f7xx_hal_gpio.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_uart.c
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/STemWin/Config
    ../Src/: LCDConf.c GUIConf.c
    ../../../../../../Middlewares/ST/STemWin/OS/: GUI_X.c
software components: CMSIS:CORE 4.1.0
